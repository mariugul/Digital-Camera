[aimspice]
[description]
1436
Digital Camera - Analog Pixel Circuit

*<name> <drain> <gate> <source> <bulk> <type> <L>  <W>

.include p18_cmos_models.inc
.include p18_model_card.inc
.include PhotoDiode.inc
.include example_testbench.cir

* PIXEL 1.1
MN111 N111 EXPOSE N112  0   NMOS L=0.36u W=1080u    	!Switch
MN112 N112 ERASE  0   0   NMOS L=0.36u W=1080u        !Switch
MP113 0  N112     N113  1 PMOS L=0.36u W=1080u     	!Amplifier
MP114 N113 NRE_R1 OUT1 1 PMOS L=0.36u W=1080u     	!Switch
CS11 N112 0 3pf

* PIXEL 1.2
MN121 N121 EXPOSE N122  0   NMOS L=0.36u W=1080u
MN122 N122 ERASE  0   0   NMOS L=0.36u W=1080u
MP123 0  N122     N123  1 PMOS L=0.36u W=1080u
MP124 N123 NRE_R1 OUT2 1 PMOS L=0.36u W=1080u
CS12 N122 0 3pf

* PIXEL 2.1
MN211 N211 EXPOSE N212   0   NMOS L=0.36u W=1080u
MN212 N212 ERASE  0    0   NMOS L=0.36u W=1080u
MP213 0  N212     N213   1 PMOS L=0.36u W=1080u
MP214 N213 NRE_R2 OUT1 1 PMOS L=0.36u W=1080u
CS21 N212 0 3pf

* PIXEL 2.2
MN221 N221 EXPOSE N222   0   NMOS L=0.36u W=1080u
MN222 N222 ERASE  0    0   NMOS L=0.36u W=1080u
MP223 0  N222     N223   1 PMOS L=0.36u W=1080u
MP224 N223 NRE_R2 OUT2 1 PMOS L=0.36u W=1080u
CS22 N222 0 3pf

* MC1 *
MC1 OUT1 OUT1 1 1 PMOS L=0.36u W=1080u  !Amplifier

* CC1 *
CC1 OUT1 0 3pf

* MC2 *
MC2 OUT2 OUT2 1 1 PMOS L=0.36u W=1080u    !Amplifier

* CC2 *
CC2 OUT2 0 3pf
[tran]
0.001
0.06
X
X
0
[ana]
4 0
[end]
